## sdkconfig.defaults
```kconfig
CONFIG_MAIN_TASK_STACK_SIZE=16384
CONFIG_MBEDTLS_CMAC_C=y
CONFIG_MBEDTLS_DES_C=y
```
